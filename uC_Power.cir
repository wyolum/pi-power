* EESchema Netlist Version 1.1 (Spice format) creation date: 21-Sep-13 12:17:35 PM

* To exclude a component from the Spice Netlist add [Spice_Netlist_Enabled] user FIELD set to: N
* To reorder the component spice node sequence add [Spice_Node_Sequence] user FIELD and define sequence: 2,1,0

*Sheet Name:/
R18  /5V_IN N-000033 10k
J4  GND N-000040 /5V_IN Auto_On
SW1  N-000033 GND ON_OFF
C14  /5V_Pi N-000032 10uF
R20  /5V_Pi N-000031 100k
R22  N-000031 N-000032 300k
R21  N-000031 /GPIO4 1k
C13  N-000040 N-000034 100nF
R19  /5V_IN N-000034 100k
C17  N-000033 N-000034 1uF
Q2  GND N-000032 /5V_IN N-000034 /5V_Pi /5V_Pi N-000034 N-000034 IRF7319
J1  N-000007 ? ? ? GND MicroUSB_in
D4  N-000004 /STAT CHG
R1  /5V_IN N-000004 1k5
C5  /5V_IN GND 10u
R3  /PROG GND 2k
C6  /VBAT GND 10u
J2  /VBAT GND LiPo_JST
U1  /STAT GND /VBAT /5V_IN /PROG MCP73831
U4  /VAUX /5V_BAT /L GND /VBAT /EN /UVLO2V6 /PS GND /FB GND GND GND GND GND TPS61200
C9  /VBAT GND 10uF
C7  /UVLO2V6 /VBAT 100nF
R4  /VBAT /UVLO2V6 2M
R12  /UVLO2V6 GND 220k
SJ2  /UVLO2V6 /VBAT UVLO
C8  GND /VAUX 100nF
R8  /5V_BAT /FB 2M
R13  /FB GND 220k
C10  /5V_BAT GND 22uF
R6  /VBAT /PS 10k
R7  /VBAT /EN 10k
L1  /VBAT /L 4u7H,1.2A
D5  /5V_BAT /5V_IN LSM115J
Q1  /EN N-000008 GND 2SK3019
R5  /5V_IN N-000008 100k
SJ1  /5V_IN /5V_BAT LINK1
P2  /PWR_IN GND GND V_IN
D1  /PWR_IN N-000005 LSM115J
C1  GND /5V_EXT 100nF
C2  N-000005 GND 100u,25V
C3  /5V_EXT GND 2u2 Tant
J3  /5V_USB ? ? GND GND USB_A_out
D3  /STAT N-000003 DIS
R2  N-000003 GND 1k5
F1  /5V_USB N-000007 NANOSMDC110F
D2  /5V_USB GND SMBJ5.0CA
C4  GND /5V_IN 100nF
R9  /5V_BAT N-000006 1k5
D6  N-000006 GND BAT
U3  N-000065 /D0 /D1 /Ilim GND /5V_USB /5V_IN /5V_EXT TPS2115A
R10  /Ilim GND 470E
C11  GND /5V_EXT 100nF
C12  GND /5V_USB 100nF
R11  N-000065 N-000066 1k5
D7  /5V_IN N-000066 EXT_ON
U5  GND N-000061 N-000059 GND GND GND /SCL_Pi /SDA_Pi GND MAX17040
R14  /VBAT N-000061 1k
C15  GND N-000061 1uF
C16  GND N-000059 100nF
R15  /3V3_Pi N-000059 150E
R16  /3V3_Pi /SDA_Pi 10k
R17  /3V3_Pi /SCL_Pi 10k
SJ4  /D1 GND D1
SJ3  /D0 N-000060 D0
TP1  N-000060 TP
J8  /VBAT GND VBAT
J9  /5V_BAT GND 5V_BAT
J6  /5V_EXT GND 5V_EXT
J7  /5V_IN GND 5V_IN
P1  /3V3_Pi /5V_Pi /SDA_Pi ? /SCL_Pi GND /GPIO4 ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? ? RASPI_GPIO
J10  /5V_Pi GND 5V_Pi
D9  N-000031 N-000033 LSM115J
H1  ? MH
H2  ? MH
J11  /PWR_IN GND /PWR_IN GND 12V_Out
J5  /5V_USB GND 5V_USB
U2  GND /5V_EXT N-000005 NCP1117ST50
PCB1  ? PCB

.end
